## app/Kconfig
```kconfig
source "Kconfig.zephyr"

config APP_HEARTBEAT_PERIOD_MS
    int "Heartbeat LED period (ms)"
    default 500
    range 100 2000
```
